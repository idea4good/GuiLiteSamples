# IAR project DISCO-F429ZI_LCD_demo.ewp, settings and files
configuration DISCO-F429ZI_LCD_demo (ARM, debug)
  General.OGChipSelectEditMenu: STM32F429ZI ST STM32F429ZI
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDiagSuppress: Pa050,Pa084,Pa093,Pa082
  ICCARM.IExtraOptions: -DDEVICE_RTC=1; --enable_restrict; --guard_calls; -DTARGET_STM32F429xI; -DTARGET_STM32F4; -DDEVICE_SLEEP=1; -DTARGET_RELEASE; -D__MBED_CMSIS_RTOS_CM; -DMBED_BUILD_TIMESTAMP=1547466512.1; --diag_suppress=Pa050,Pa084,Pa093,Pa082; -DDEVICE_PORTINOUT=1; -e; -DDEVICE_I2C_ASYNCH=1; -DTARGET_RTOS_M4_M7; -DTARGET_STM32F429xx; -DDEVICE_SPISLAVE=1; -DDEVICE_PORTOUT=1; -DDEVICE_FLASH=1; -DDEVICE_STDIO_MESSAGES=1; -DDEVICE_ANALOGOUT=1; -DMBED_ROM_SIZE=0x200000; -DDEVICE_SERIAL_FC=1; -DDEVICE_INTERRUPTIN=1; -DTARGET_M4; -DDEVICE_ANALOGIN=1; -DTARGET_LIKE_CORTEX_M4; -DTARGET_STM32F429; --preinclude=mbed_config.h; -DTARGET_CORTEX_M; -DDEVICE_SERIAL=1; -DTARGET_DISCO_F429ZI; -DUSB_STM_HAL; -DTARGET_STM32F429ZI; -DDEVICE_USTICKER=1; -DDEVICE_I2C=1; -D__CORTEX_M4; -DARM_MATH_CM4; -DTARGET_STM; -D__CMSIS_RTOS; --no_wrap_diagnostics; -DDEVICE_PWMOUT=1; -DTARGET_CORTEX; -DDEVICE_SERIAL_ASYNCH=1; -DDEVICE_TRNG=1; -DTARGET_FAMILY_STM32; -DDEVICE_SPI=1; -D__MBED__=1; -DTOOLCHAIN_IAR; --diag_suppress=Pe546; -DDEVICE_LPTICKER=1; -DDEVICE_PORTIN=1; -DMBED_ROM_START=0x8000000; -D__FPU_PRESENT=1; -DDEVICE_I2CSLAVE=1; -DUSBHOST_OTHER; -DDEVICE_SPI_ASYNCH=1; -DTRANSACTION_QUEUE_SIZE_SPI=2; -DDEVICE_CAN=1; -DTARGET_LIKE_MBED
  ICCARM.CCIncludePath2: .; BSP_DISCO_F429ZI; BSP_DISCO_F429ZI/Drivers; BSP_DISCO_F429ZI/Drivers/BSP; BSP_DISCO_F429ZI/Drivers/BSP/Components; BSP_DISCO_F429ZI/Drivers/BSP/Components/Common; BSP_DISCO_F429ZI/Drivers/BSP/Components/ili9341; BSP_DISCO_F429ZI/Drivers/BSP/Components/l3gd20; BSP_DISCO_F429ZI/Drivers/BSP/Components/stmpe811; BSP_DISCO_F429ZI/Drivers/BSP/STM32F429I-Discovery; BSP_DISCO_F429ZI/Utilities; BSP_DISCO_F429ZI/Utilities/Fonts; LCD_DISCO_F429ZI; mbed; mbed/TARGET_DISCO_F429ZI/TOOLCHAIN_IAR; mbed/drivers; mbed/hal; mbed/platform; GUI_Lite/core; GUI_Lite/gui
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.AExtraOptionsV2: -DTRANSACTION_QUEUE_SIZE_SPI=2; -D__CORTEX_M4; -DUSB_STM_HAL; -DARM_MATH_CM4; -D__FPU_PRESENT=1; -DUSBHOST_OTHER; -D__MBED_CMSIS_RTOS_CM; -D__CMSIS_RTOS; "-DMBED_CONF_PLATFORM_ERROR_HIST_ENABLED=0"; "-DMBED_CONF_PLATFORM_STDIO_FLUSH_AT_EXIT=1"; "-DMBED_MEM_TRACING_ENABLED=0"; "-DMBED_CONF_PLATFORM_POLL_USE_LOWPOWER_TIMER=0"; "-DMBED_CONF_PLATFORM_FORCE_NON_COPYABLE_ERROR=0"; "-DMBED_CONF_PLATFORM_STDIO_BAUD_RATE=9600"; "-DCLOCK_SOURCE=USE_PLL_HSE_XTAL|USE_PLL_HSI"; "-DMBED_CONF_PLATFORM_STDIO_BUFFERED_SERIAL=0"; "-DMBED_CONF_PLATFORM_DEFAULT_SERIAL_BAUD_RATE=9600"; "-DLPTICKER_DELAY_TICKS=1"; "-DMBED_CONF_PLATFORM_ERROR_ALL_THREADS_INFO=0"; "-DMBED_CONF_PLATFORM_MAX_ERROR_FILENAME_LEN=16"; "-DCLOCK_SOURCE_USB=1"; "-DMBED_CONF_TARGET_LPUART_CLOCK_SOURCE=USE_LPUART_CLK_LSE|USE_LPUART_CLK_PCLK1"; "-DMBED_CONF_PLATFORM_ERROR_HIST_SIZE=4"; "-DMBED_CONF_PLATFORM_STDIO_CONVERT_TTY_NEWLINES=0"; "-DMBED_CONF_PLATFORM_ERROR_FILENAME_CAPTURE_ENABLED=0"; "-DMBED_CONF_PLATFORM_STDIO_CONVERT_NEWLINES=0"; "-DMBED_CONF_TARGET_LSE_AVAILABLE=0"
  OBJCOPY.OOCOutputFile: DISCO-F429ZI_LCD_demo.bin
  ILINK.IlinkOutputFile: name.out
  ILINK.IlinkIcfFile: mbed/TARGET_DISCO_F429ZI/TOOLCHAIN_IAR/stm32f429xx_flash.icf
  ILINK.IlinkExtraOptions: --skip_dynamic_initialization; --threaded_lib
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group BSP_DISCO_F429ZI
    BSP_DISCO_F429ZI/Utilities/Fonts/: font12.c font16.c font20.c font24.c font8.c fonts.h
    BSP_DISCO_F429ZI/Drivers/BSP/Components/Common/: gyro.h io.h lcd.h ts.h
    BSP_DISCO_F429ZI/Drivers/BSP/Components/ili9341/: ili9341.c ili9341.h
    BSP_DISCO_F429ZI/Drivers/BSP/Components/l3gd20/: l3gd20.c l3gd20.h
    BSP_DISCO_F429ZI/Drivers/BSP/STM32F429I-Discovery/: stm32f429i_discovery.c stm32f429i_discovery.h stm32f429i_discovery_eeprom.c stm32f429i_discovery_eeprom.h stm32f429i_discovery_gyroscope.c stm32f429i_discovery_gyroscope.h stm32f429i_discovery_io.c stm32f429i_discovery_io.h stm32f429i_discovery_lcd.c stm32f429i_discovery_lcd.h stm32f429i_discovery_sdram.c stm32f429i_discovery_sdram.h stm32f429i_discovery_ts.c stm32f429i_discovery_ts.h
    BSP_DISCO_F429ZI/Drivers/BSP/Components/stmpe811/: stmpe811.c stmpe811.h
  group DISCO-F429ZI_LCD_demo
    ./: Lucida_Console_48.cpp main.cpp mbed_config.h Microsoft_YaHei_25.cpp UIcode.cpp
  group GUI_Lite/core
    GUI_Lite/core/src/adapter/: api_none.cpp msg_none.cpp
    GUI_Lite/core/src/: bitmap.cpp cmd_target.cpp display.cpp rect.cpp surface.cpp wave_buffer.cpp wave_ctrl.cpp wnd.cpp word.cpp
  group GUI_Lite/gui
    GUI_Lite/gui/src/: button.cpp dialog.cpp edit.cpp gesture.cpp keyboard.cpp label.cpp list_box.cpp my_resource.cpp slide_group.cpp spinbox.cpp table.cpp
  group LCD_DISCO_F429ZI
    LCD_DISCO_F429ZI/: LCD_DISCO_F429ZI.cpp LCD_DISCO_F429ZI.h
  group mbed
    mbed/drivers/: AnalogIn.h AnalogOut.h BusIn.h BusInOut.h BusOut.h CAN.h DigitalIn.h DigitalInOut.h DigitalOut.h Ethernet.h FlashIAP.h I2C.h I2CSlave.h InterruptIn.h InterruptManager.h LowPowerTicker.h LowPowerTimeout.h LowPowerTimer.h MbedCRC.h PortIn.h PortInOut.h PortOut.h PwmOut.h QSPI.h RawSerial.h Serial.h SerialBase.h SerialWireOutput.h SPI.h SPISlave.h TableCRC.h Ticker.h Timeout.h Timer.h TimerEvent.h UARTSerial.h
    mbed/hal/: analogin_api.h analogout_api.h buffer.h can_api.h can_helper.h crc_api.h critical_section_api.h dma_api.h Driver_Common.h Driver_Storage.h ethernet_api.h flash_api.h flash_data.h gpio_api.h gpio_irq_api.h i2c_api.h itm_api.h LowPowerTickerWrapper.h lp_ticker_api.h mbed_lp_ticker_wrapper.h pinmap.h port_api.h pwmout_api.h qspi_api.h rtc_api.h serial_api.h sleep_api.h spi_api.h ticker_api.h trng_api.h us_ticker_api.h
    mbed/TARGET_DISCO_F429ZI/TOOLCHAIN_IAR/: analogin_api.o analogin_device.o analogout_api.o analogout_device.o arm_math.h can_api.o can_device.h cmain.o cmsis.h cmsis_armcc.h cmsis_armclang.h cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_nvic.h cmsis_version.h common_objects.h core_armv8mbl.h core_armv8mml.h core_cm0.h core_cm0plus.h core_cm1.h core_cm23.h core_cm3.h core_cm33.h core_cm4.h core_cm7.h core_sc000.h core_sc300.h device.h flash_api.o flash_data.h gpio_api.o gpio_irq_api.o gpio_irq_device.h gpio_irq_device.o gpio_object.h hal_init_pre.o hal_tick_overrides.o i2c_api.o i2c_device.h lp_ticker.o mbed.a mbed_board.o mbed_cmsis_conf.h mbed_crc_api.o mbed_overrides.o mbed_retarget.o mbed_rtx.h mbed_sdk_boot.o mbed_tz_context.o mpu_armv7.h mpu_armv8.h nvic_addr.h objects.h PeripheralNames.h PeripheralPins.h PeripheralPins.o pin_device.h pinmap.o PinNames.h PinNamesTypes.h port_api.o PortNames.h pwmout_api.o pwmout_device.h pwmout_device.o qspi_api.o rtc_api.o rtc_api_hal.h RTE_Components.h serial_api.o serial_api_hal.h serial_device.o sleep.o spi_api.o spi_device.h startup_stm32f429xx.o stm32_assert.h stm32_hal_legacy.h stm32f429xx.h stm32f4xx.h stm32f4xx_hal.h stm32f4xx_hal.o stm32f4xx_hal_adc.h stm32f4xx_hal_adc.o stm32f4xx_hal_adc_ex.h stm32f4xx_hal_adc_ex.o stm32f4xx_hal_can.h stm32f4xx_hal_can.o stm32f4xx_hal_can_legacy.h stm32f4xx_hal_can_legacy.o stm32f4xx_hal_cec.h stm32f4xx_hal_cec.o stm32f4xx_hal_conf.h stm32f4xx_hal_cortex.h stm32f4xx_hal_cortex.o stm32f4xx_hal_crc.h stm32f4xx_hal_crc.o stm32f4xx_hal_cryp.h stm32f4xx_hal_cryp.o stm32f4xx_hal_cryp_ex.h stm32f4xx_hal_cryp_ex.o stm32f4xx_hal_dac.h stm32f4xx_hal_dac.o stm32f4xx_hal_dac_ex.h stm32f4xx_hal_dac_ex.o stm32f4xx_hal_dcmi.h stm32f4xx_hal_dcmi.o stm32f4xx_hal_dcmi_ex.h stm32f4xx_hal_dcmi_ex.o stm32f4xx_hal_def.h stm32f4xx_hal_dfsdm.h stm32f4xx_hal_dfsdm.o stm32f4xx_hal_dma.h stm32f4xx_hal_dma.o stm32f4xx_hal_dma2d.h stm32f4xx_hal_dma2d.o stm32f4xx_hal_dma_ex.h stm32f4xx_hal_dma_ex.o stm32f4xx_hal_dsi.h stm32f4xx_hal_dsi.o stm32f4xx_hal_eth.h stm32f4xx_hal_eth.o stm32f4xx_hal_flash.h stm32f4xx_hal_flash.o stm32f4xx_hal_flash_ex.h stm32f4xx_hal_flash_ex.o stm32f4xx_hal_flash_ramfunc.h stm32f4xx_hal_flash_ramfunc.o stm32f4xx_hal_fmpi2c.h stm32f4xx_hal_fmpi2c.o stm32f4xx_hal_fmpi2c_ex.h stm32f4xx_hal_fmpi2c_ex.o stm32f4xx_hal_gpio.h stm32f4xx_hal_gpio.o stm32f4xx_hal_gpio_ex.h stm32f4xx_hal_hash.h stm32f4xx_hal_hash.o stm32f4xx_hal_hash_ex.h stm32f4xx_hal_hash_ex.o stm32f4xx_hal_hcd.h stm32f4xx_hal_hcd.o stm32f4xx_hal_i2c.h stm32f4xx_hal_i2c.o stm32f4xx_hal_i2c_ex.h stm32f4xx_hal_i2c_ex.o stm32f4xx_hal_i2s.h stm32f4xx_hal_i2s.o stm32f4xx_hal_i2s_ex.h stm32f4xx_hal_i2s_ex.o stm32f4xx_hal_irda.h stm32f4xx_hal_irda.o stm32f4xx_hal_iwdg.h stm32f4xx_hal_iwdg.o stm32f4xx_hal_lptim.h stm32f4xx_hal_lptim.o stm32f4xx_hal_ltdc.h stm32f4xx_hal_ltdc.o stm32f4xx_hal_ltdc_ex.h stm32f4xx_hal_ltdc_ex.o stm32f4xx_hal_mmc.h stm32f4xx_hal_mmc.o stm32f4xx_hal_nand.h stm32f4xx_hal_nand.o stm32f4xx_hal_nor.h stm32f4xx_hal_nor.o stm32f4xx_hal_pccard.h stm32f4xx_hal_pccard.o stm32f4xx_hal_pcd.h stm32f4xx_hal_pcd.o stm32f4xx_hal_pcd_ex.h stm32f4xx_hal_pcd_ex.o stm32f4xx_hal_pwr.h stm32f4xx_hal_pwr.o stm32f4xx_hal_pwr_ex.h stm32f4xx_hal_pwr_ex.o stm32f4xx_hal_qspi.h stm32f4xx_hal_qspi.o stm32f4xx_hal_rcc.h stm32f4xx_hal_rcc.o stm32f4xx_hal_rcc_ex.h stm32f4xx_hal_rcc_ex.o stm32f4xx_hal_rng.h stm32f4xx_hal_rng.o stm32f4xx_hal_rtc.h stm32f4xx_hal_rtc.o stm32f4xx_hal_rtc_ex.h stm32f4xx_hal_rtc_ex.o stm32f4xx_hal_sai.h stm32f4xx_hal_sai.o stm32f4xx_hal_sai_ex.h stm32f4xx_hal_sai_ex.o stm32f4xx_hal_sd.h stm32f4xx_hal_sd.o stm32f4xx_hal_sdram.h stm32f4xx_hal_sdram.o stm32f4xx_hal_smartcard.h stm32f4xx_hal_smartcard.o stm32f4xx_hal_spdifrx.h stm32f4xx_hal_spdifrx.o stm32f4xx_hal_spi.h stm32f4xx_hal_spi.o stm32f4xx_hal_sram.h stm32f4xx_hal_sram.o stm32f4xx_hal_tim.h stm32f4xx_hal_tim.o stm32f4xx_hal_tim_ex.h stm32f4xx_hal_tim_ex.o stm32f4xx_hal_uart.h stm32f4xx_hal_uart.o stm32f4xx_hal_usart.h stm32f4xx_hal_usart.o stm32f4xx_hal_wwdg.h stm32f4xx_hal_wwdg.o stm32f4xx_ll_adc.h stm32f4xx_ll_adc.o stm32f4xx_ll_bus.h stm32f4xx_ll_cortex.h stm32f4xx_ll_crc.h stm32f4xx_ll_crc.o stm32f4xx_ll_dac.h stm32f4xx_ll_dac.o stm32f4xx_ll_dma.h stm32f4xx_ll_dma.o stm32f4xx_ll_dma2d.h stm32f4xx_ll_dma2d.o stm32f4xx_ll_exti.h stm32f4xx_ll_exti.o stm32f4xx_ll_fmc.h stm32f4xx_ll_fmc.o stm32f4xx_ll_fsmc.h stm32f4xx_ll_fsmc.o stm32f4xx_ll_gpio.h stm32f4xx_ll_gpio.o stm32f4xx_ll_i2c.h stm32f4xx_ll_i2c.o stm32f4xx_ll_iwdg.h stm32f4xx_ll_lptim.h stm32f4xx_ll_lptim.o stm32f4xx_ll_pwr.h stm32f4xx_ll_pwr.o stm32f4xx_ll_rcc.h stm32f4xx_ll_rcc.o stm32f4xx_ll_rng.h stm32f4xx_ll_rng.o stm32f4xx_ll_rtc.h stm32f4xx_ll_rtc.o stm32f4xx_ll_sdmmc.h stm32f4xx_ll_sdmmc.o stm32f4xx_ll_spi.h stm32f4xx_ll_spi.o stm32f4xx_ll_system.h stm32f4xx_ll_tim.h stm32f4xx_ll_tim.o stm32f4xx_ll_usart.h stm32f4xx_ll_usart.o stm32f4xx_ll_usb.h stm32f4xx_ll_usb.o stm32f4xx_ll_utils.h stm32f4xx_ll_utils.o stm32f4xx_ll_wwdg.h stm_spi_api.o system_clock.o system_init_pre.o system_stm32f4xx.h system_stm32f4xx.o trng_api.o tz_context.h us_ticker.o us_ticker_data.h
    mbed/platform/: ATCmdParser.h Callback.h CallChain.h CircularBuffer.h critical.h CriticalSectionLock.h CThunk.h DeepSleepLock.h DirHandle.h FileBase.h FileHandle.h FileLike.h FilePath.h FileSystemHandle.h FileSystemLike.h FunctionPointer.h LocalFileSystem.h mbed_application.h mbed_assert.h mbed_critical.h mbed_debug.h mbed_error.h mbed_error_hist.h mbed_interface.h mbed_mem_trace.h mbed_mktime.h mbed_poll.h mbed_power_mgmt.h mbed_preprocessor.h mbed_retarget.h mbed_rtc_time.h mbed_semihost_api.h mbed_sleep.h mbed_stats.h mbed_toolchain.h mbed_version.h mbed_wait_api.h NonCopyable.h platform.h PlatformMutex.h rtc_time.h ScopedLock.h semihost_api.h SharedPtr.h SingletonPtr.h sleep.h Span.h Stream.h toolchain.h Transaction.h wait_api.h
    mbed/: mbed.h
