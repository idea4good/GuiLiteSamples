# Keil uVision project HelloMario.uvprojx, settings and files
target HelloMario (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: HelloMario +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\HARDWARE\LED;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\STM32F10x_FWLib\inc;..\CORE;..\HARDWARE\KEY;..\HARDWARE\LCD
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/LCD/: lcd.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLib
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c
  group README
    ../: README.TXT
  group UIcode
    ../../UIcode/: UIcode.cpp
    ../../UIcode/resource/: background_bmp.cpp jump_bmp.cpp step1_bmp.cpp step2_bmp.cpp step3_bmp.cpp frame_00_bmp.cpp frame_01_bmp.cpp frame_02_bmp.cpp frame_03_bmp.cpp frame_04_bmp.cpp frame_05_bmp.cpp frame_06_bmp.cpp frame_07_bmp.cpp frame_08_bmp.cpp frame_09_bmp.cpp frame_10_bmp.cpp frame_11_bmp.cpp frame_12_bmp.cpp frame_13_bmp.cpp title_bmp.cpp
