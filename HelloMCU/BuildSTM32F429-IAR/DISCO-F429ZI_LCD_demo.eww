<?xml version="1.0" encoding="utf-8"?>
<workspace>
	<project>
		<path>$WS_DIR$/DISCO-F429ZI_LCD_demo.ewp</path>
	</project>
	<batchBuild></batchBuild>
</workspace>